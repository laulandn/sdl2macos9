
#include <pthread.h>
#include <stdio.h>


/* Because obviously classic MacOS does not have pthreads, just dummies, probably wrong... */


static int last_id=0;


int pthread_mutex_init(pthread_mutex_t *m, const pthread_mutexattr *a)
{
  /*printf("pthread_mutex_init  stub called!\n");*/
  if(!m) { printf("thread m was NULL!\n"); return 1; }
  if(!*m) { /*printf("thread *m was NULL!\n");*/ return 1; }
  if(!a) printf("attributes a was NULL!\n");
  (*m)->id=last_id;
  last_id++;
  (*m)->locked=0;
  return 0;
}


int pthread_mutex_lock(pthread_mutex_t *m)
{
  /*printf("pthread_mutex_lock  stub called!\n");*/
  if(!m) { printf("thread m was NULL!\n"); return 1; }
  if(!*m) { /*printf("thread *m was NULL!\n");*/ return 1; }
  (*m)->locked=1;
  return 0;
}


int pthread_mutex_unlock(pthread_mutex_t *m)
{
  /*printf("pthread_mutex_unlock  stub called!\n");*/
  if(!m) { printf("thread m was NULL!\n"); return 1; }
  if(!*m) { /*printf("thread *m was NULL!\n");*/ return 1; }
  (*m)->locked=1;
  return 0;
}


void *pthread_mutex_initializer()
{
  return (void *)calloc(1,sizeof(struct pthread_mutex_t_struct));
}